# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC131SD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IROM(0x00000000,0x11000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: test
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\FreeRTOSv10.2.1\FreeRTOS\Source\include;..\FreeRTOSv10.2.1\FreeRTOS\Source\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c
    ../../../Do An/NUC131Series_BSP_CMSIS_v3.00.004/Library/StdDriver/src/: gpio.c clk.c sys.c
    ../FreeRTOSv10.2.1/FreeRTOS/Source/: timers.c tasks.c queue.c list.c event_groups.c croutine.c
    ../FreeRTOSv10.2.1/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../FreeRTOSv10.2.1/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
software components: CMSIS:CORE 5.3.0, Device:Startup 0.00.001
